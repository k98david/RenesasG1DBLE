# IAR project Sample.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R5F11AGJ RL78 - R5F11AGJ
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 1024
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: _USE_IAR_RL78; noUSE_SAMPLE_PROFILE
  ICCRL78.CCDiagSuppress: Pa050, Go005, Pe177, Pe111, Pe167
  ICCRL78.CCIncludePath2: ..\..\..\..\src\Platform\G1D_cs_iar\driver\console; ..\..\..\..\src\Platform\G1D_cs_iar\driver\serial; ..\..\..\..\src\Platform\G1D_cs_iar\driver\plf; ..\..\..\..\src\Platform\G1D_cs_iar\driver\led; ..\..\..\..\src\Platform\G1D_cs_iar\driver\timer; ..\..\..\..\src\Platform\G1D_cs_iar\include; ..\..\..\..\src\rBLE\src\include; ..\..\..\..\src\rBLE\src\include\host; ..\..\..\..\src\rBLE\src\rscip; ..\..\..\..\src\rBLE\src\sample_app; ..\..\..\..\src\rBLE\src\sample_profile
  OBJCOPY.OOCOutputFile: rBLE_sample.hex
  ILINK.IlinkOutputFile: rBLE_sample.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: _USE_IAR_RL78; noUSE_SAMPLE_PROFILE; noUSE_FW_UPDATE_PROFILE
  group (top)
    ../../../../src/Platform/G1D_cs_iar/: rBLE_Sample.c
  group Driver/console
    ../../../../src/Platform/G1D_cs_iar/driver/console/: Console.c
  group Driver/led
    ../../../../src/Platform/G1D_cs_iar/driver/led/: led.c
  group Driver/plf
    ../../../../src/Platform/G1D_cs_iar/driver/plf/: plf.c
  group Driver/serial
    ../../../../src/Platform/G1D_cs_iar/driver/serial/: serial.h term_uart.c term_uart.h uart.c uart.h
  group Driver/timer
    ../../../../src/Platform/G1D_cs_iar/driver/timer/: timer.c
  group rBLE/src/host
    ../../../../src/rBLE/src/host/: rble_host.c rble_if_api_cb.c
  group rBLE/src/host/anp
    ../../../../src/rBLE/src/host/anp/: rble_api_anpc.c rble_api_anps.c
  group rBLE/src/host/blp
    ../../../../src/rBLE/src/host/blp/: rble_api_blpc.c rble_api_blps.c
  group rBLE/src/host/cpp
    ../../../../src/rBLE/src/host/cpp/: rble_api_cppc.c rble_api_cpps.c
  group rBLE/src/host/cscp
    ../../../../src/rBLE/src/host/cscp/: rble_api_cscpc.c rble_api_cscps.c
  group rBLE/src/host/fmp
    ../../../../src/rBLE/src/host/fmp/: rble_api_fmpl.c rble_api_fmpt.c
  group rBLE/src/host/gap
    ../../../../src/rBLE/src/host/gap/: rble_api_gap.c
  group rBLE/src/host/gatt
    ../../../../src/rBLE/src/host/gatt/: rble_api_gatt.c
  group rBLE/src/host/glp
    ../../../../src/rBLE/src/host/glp/: rble_api_glpc.c rble_api_glps.c
  group rBLE/src/host/hogp
    ../../../../src/rBLE/src/host/hogp/: rble_api_hgbh.c rble_api_hghd.c rble_api_hgrh.c
  group rBLE/src/host/hrp
    ../../../../src/rBLE/src/host/hrp/: rble_api_hrpc.c rble_api_hrps.c
  group rBLE/src/host/htp
    ../../../../src/rBLE/src/host/htp/: rble_api_htpc.c rble_api_htpt.c
  group rBLE/src/host/lnp
    ../../../../src/rBLE/src/host/lnp/: rble_api_lnpc.c rble_api_lnps.c
  group rBLE/src/host/pasp
    ../../../../src/rBLE/src/host/pasp/: rble_api_paspc.c rble_api_pasps.c
  group rBLE/src/host/pxp
    ../../../../src/rBLE/src/host/pxp/: rble_api_pxpm.c rble_api_pxpr.c
  group rBLE/src/host/rscp
    ../../../../src/rBLE/src/host/rscp/: rble_api_rscpc.c rble_api_rscps.c
  group rBLE/src/host/scpp
    ../../../../src/rBLE/src/host/scpp/: rble_api_sppc.c rble_api_spps.c
  group rBLE/src/host/sm
    ../../../../src/rBLE/src/host/sm/: rble_api_sm.c
  group rBLE/src/host/vs
    ../../../../src/rBLE/src/host/vs/: rble_api_vs.c
  group rBLE/src/rscip
    ../../../../src/rBLE/src/rscip/: rscip.c rscip_cntl.c rscip_uart.c
  group rBLE/src/sample_app
    ../../../../src/rBLE/src/sample_app/: menu_sel.c rble_sample_app.c rble_sample_app_anp.c rble_sample_app_blp.c rble_sample_app_cpp.c rble_sample_app_cscp.c rble_sample_app_custom.c rble_sample_app_fmp.c rble_sample_app_fwup.c rble_sample_app_gap_sm_gatt.c rble_sample_app_glp.c rble_sample_app_hogp.c rble_sample_app_hrp.c rble_sample_app_htp.c rble_sample_app_lnp.c rble_sample_app_pasp.c rble_sample_app_pxp.c rble_sample_app_rscp.c rble_sample_app_scpp.c rble_sample_app_tip.c rble_sample_app_vendor.c
  group rBLE/src/sample_profile/fwup
    ../../../../src/rBLE/src/sample_profile/fwup/: fwups.c
  group rBLE/src/sample_profile/scp
    ../../../../src/rBLE/src/sample_profile/scp/: scpc.c scps.c
