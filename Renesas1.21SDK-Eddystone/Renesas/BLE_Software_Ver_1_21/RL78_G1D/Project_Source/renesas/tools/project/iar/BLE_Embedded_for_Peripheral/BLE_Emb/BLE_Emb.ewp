# IAR project BLE_Emb.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 4096
  General.GenDeviceSelect: R5F11AGJ RL78 - R5F11AGJ
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 800
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: CFG_FULLEMB; CFG_CON=1; CFG_EXMEM_NOT_PRESENT; CFG_BLECORE_10; CFG_PROFEMB; CFG_SECURITY_ON; CFG_RBLE; CFG_USE_EEL; CFG_FW_NAK; CONFIG_EMBEDDED; _USE_IAR_RL78; CFG_SAMPLE; CLK_HOCO_8MHZ; CLK_SUB_XT1; USE_SAMPLE_PROFILE; noCFG_USE_PEAK; noUSE_FW_UPDATE_PROFILE; noCFG_PKTMON; CFG_SECLIB_BOND_NUM=4; USE_SECLIB
  ICCRL78.CCDiagSuppress: Pa050, Go005, Pe177, Pe111, Pe167
  ICCRL78.CCIncludePath2: ..\..\..\..\..\src\driver\serial; ..\..\..\..\..\src\driver\wakeup; ..\..\..\..\..\src\driver\dataflash; ..\..\..\..\..\src\driver\dataflash\iar; ..\..\..\..\..\src\driver\DTM2Wire; ..\..\..\..\..\src; ..\..\..\..\..\src\compiler; ..\..\..\..\..\src\arch\rl78; ..\..\..\..\..\src\arch\rl78\ll; ..\..\..\..\..\src\driver\led; ..\..\..\..\..\src\driver\plf; ..\..\..\..\..\src\driver\port; ..\..\..\..\..\src\driver\rf; ..\..\..\..\..\src\driver\uart; ..\..\..\..\..\src\driver\push_sw; ..\..\..\..\..\src\driver\pktmon; ..\..\..\..\..\..\bleip\src\common; ..\..\..\..\..\..\bleip\src\rwble; .\; ..\..\..\..\..\..\rble\src\include; ..\..\..\..\..\..\rBLE\src\sample_app; ..\..\..\..\..\..\rBLE\src\sample_app\seclib; ..\..\..\..\..\..\rBLE\src\sample_profile; ..\..\..\..\..\src\driver\led_onoff; ..\..\..\..\..\src\driver\push_state
  XLINK.XclFile: ..\..\CONFIG\lnkr5f11agj.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCIncludePath2: ..\..\..\..\..\src\driver\serial; ..\..\..\..\..\src\driver\wakeup; ..\..\..\..\..\src\driver\dataflash\iar; ..\..\..\..\..\src\driver\dataflash; ..\..\..\..\..\src\driver\DTM2Wire; ..\..\..\..\..\src; ..\..\..\..\..\src\compiler; ..\..\..\..\..\src\arch\rl78; ..\..\..\..\..\src\arch\rl78\ll; ..\..\..\..\..\src\driver\led; ..\..\..\..\..\src\driver\plf; ..\..\..\..\..\src\driver\port; ..\..\..\..\..\src\driver\rf; ..\..\..\..\..\src\driver\uart; ..\..\..\..\..\src\driver\push_sw; ..\..\..\..\..\src\driver\pktmon; ..\..\..\..\..\src\driver\led_onoff; ..\..\..\..\..\src\driver\push_state; ..\..\..\..\..\..\bleip\src\common; ..\..\..\..\..\..\bleip\src\rwble; .\; ..\..\..\..\..\..\rble\src\include; ..\..\..\..\..\..\rBLE\src\sample_app; ..\..\..\..\..\..\rBLE\src\sample_app\seclib; ..\..\..\..\..\..\rBLE\src\sample_profile
  group lib
    ../../../../../lib/: BLE_CONTROLLER_lib.r87 BLE_HOST_lib.r87 BLE_PROFILE_ANP_lib.r87 BLE_PROFILE_BLP_lib.r87 BLE_PROFILE_CPP_lib.r87 BLE_PROFILE_CSP_lib.r87 BLE_PROFILE_FMP_lib.r87 BLE_PROFILE_GLP_lib.r87 BLE_PROFILE_HGP_lib.r87 BLE_PROFILE_HRP_lib.r87 BLE_PROFILE_HTP_lib.r87 BLE_PROFILE_LNP_lib.r87 BLE_PROFILE_PAP_lib.r87 BLE_PROFILE_PXP_lib.r87 BLE_PROFILE_RSP_lib.r87 BLE_PROFILE_SCP_lib.r87 BLE_PROFILE_TIP_lib.r87 BLE_PROFILES_COMMON_lib.r87 BLE_rBLE_lib.r87
  group rBLE/sample
    ../../../../../../rBLE/src/sample_app/: console.c rble_sample_app_peripheral.c
  group rBLE/sample/seclib
    ../../../../../../rBLE/src/sample_app/seclib/: secdb.c seclib.c
  group rBLE/sample_profile/sam
    ../../../../../../rBLE/src/sample_profile/sam/: sams.c
  group renesas/arch
    ../../../../../src/arch/rl78/: arch_main.c fw_update_count0.c fw_update_count1.c ke_conf.c main.c prf_config.c prf_config_host.c rble_core_config.c rble_modem_config.c rwble_mem.c
  group renesas/driver/dataflash
    ../../../../../src/driver/dataflash/: dataflash.c eel_descriptor_t02.c fdl_descriptor_t02.c
  group renesas/driver/dataflash/lib
    ../../../../../src/driver/dataflash/iar/: eel.r87 fdl.r87
  group renesas/driver/DTM2Wire
    ../../../../../src/driver/DTM2Wire/: DTM2Wire.c
  group renesas/driver/led
    ../../../../../src/driver/led/: led.c
  group renesas/driver/led_onoff
    ../../../../../src/driver/led_onoff/: led_onoff.c
  group renesas/driver/peak
    ../../../../../src/driver/peak/: peak_isr.c
  group renesas/driver/plf
    ../../../../../src/driver/plf/: plf.c
  group renesas/driver/push_state
    ../../../../../src/driver/push_state/: push_state.c
  group renesas/driver/push_sw
    ../../../../../src/driver/push_sw/: push_sw.c
  group renesas/driver/uart
    ../../../../../src/driver/uart/: uart.c
  group renesas/driver/wakeup
    ../../../../../src/driver/wakeup/: wakeup.c
